# Keil uVision project Application_HF_Wheel_Robot.uvprojx, settings and files
target Application_HF_Wheel_Robot (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  c flags: Optim=1
  c include: .\;..\..\..\1_Processor\STM32F4\Start_Code;..\..\..\1_Processor\STM32F4\Start_Code\CMSIS;..\..\..\1_Processor\STM32F4\Start_Code\FWlib\inc;..\..\..\1_Processor\BoardAbstract;..\..\..\1_Processor\STM32F4\;..\..\..\3_OS\STM32F4\RTOS\uCOS-III\uC-CPU;..\..\..\3_OS\STM32F4\RTOS\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\3_OS\STM32F4\RTOS\uCOS-III\uC-LIB;..\..\..\3_OS\STM32F4\RTOS\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\3_OS\STM32F4\RTOS\uCOS-III\uCOS-III;..\..\..\3_OS\STM32F4\RTOS\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\3_OS\STM32F4\RTOS\uCOS-III\uCOS-III\Source;..\..\..\3_OS\STM32F4\RTOS\uCOS-III\UCOS-BSP;..\..\..\3_OS\STM32F4\RTOS\uCOS-III\uCOS-CONFIG;..\..\..\2_Package\LIB_Common;..\..\..\2_Package\LIB_Robot_Abstract;..\..\..\2_Package\LIB_Math;..\..\..\2_Package\Driver_IMU;..\..\..\2_Package\Driver_Motor;..\..\..\2_Package\Driver_Servo;..\..\..\2_Package\LIB_Robot_Wheel;..\..\..\2_Package\LIB_HF_Link;..\..\..\2_Package\LIB_Sbus_Ppm
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.cpp main_includes.h main_config.h stm32f4xx_it.cpp
  group Processor/BoardAbstract
    ../../../1_Processor/BoardAbstract/: board.h control_unit_v1.cpp control_unit_v2.cpp
  group Processor/Start_Code
    ../../../1_Processor/STM32F4/Start_Code/: stm32f4xx_conf.h
    ../../../1_Processor/STM32F4/Start_Code/CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
    ../../../1_Processor/STM32F4/Start_Code/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Processor/BSPLIB
    ../../../1_Processor/STM32F4/: bsplib.h
    ../../../1_Processor/STM32F4/BSPLIB/: adc_dac.c adc_dac.h can.c can.h delay.c delay.h encoder.c encoder.h flash.c flash.h i2c.c i2c.h nvic.c nvic.h pwm_in.c pwm_in.h pwm_out.c pwm_out.h rtc.c rtc.h spi.c spi.h timer.c timer.h usart.c usart.h wdg_wkup.c wdg_wkup.h
  group OS/RTOS/UCOSIII-BSP
    ../../../3_OS/STM32F4/RTOS/uCOS-III/UCOS-BSP/: bsp.c bsp.h
  group OS/RTOS/UCOSIII-CPU
    ../../../3_OS/STM32F4/RTOS/uCOS-III/uC-CPU/: cpu_core.c
    ../../../3_OS/STM32F4/RTOS/uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group OS/RTOS/UCOSIII-LIB
    ../../../3_OS/STM32F4/RTOS/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../3_OS/STM32F4/RTOS/uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group OS/RTOS/UCOSIII-CORE
    ../../../3_OS/STM32F4/RTOS/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group OS/RTOS/UCOSIII-PORT
    ../../../3_OS/STM32F4/RTOS/uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group OS/RTOS/UCOSIII-CONFIG
    ../../../3_OS/STM32F4/RTOS/uCOS-III/uCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Package/LIB_Common
    ../../../2_Package/LIB_Common/: queue.cpp queue.h
  group Package/LIB_Robot_Abstract
    ../../../2_Package/LIB_Robot_Abstract/: robot_abstract.cpp robot_abstract.h
  group Package/LIB_Math
    ../../../2_Package/LIB_Math/: base_math_config.h base_math_top.cpp base_math_top.h base_math_matrix.cpp base_math_matrix.h base_math_trigonometric.cpp base_math_trigonometric.h
  group Package/Driver_IMU
    ../../../2_Package/Driver_IMU/: imu_config.h imu_top.cpp imu_top.h imu_top_arithmetic_model.cpp imu_top_arithmetic_model.h imu_arithmetic_kalman.cpp imu_arithmetic_kalman.h imu_gps_driver.cpp imu_gps_driver.h imu_bmp085_driver.cpp imu_bmp085_driver.h imu_hmc5883l_driver.cpp imu_hmc5883l_driver.h imu_mpu6050_driver.cpp imu_mpu6050_driver.h
  group Package/Driver_Motor
    ../../../2_Package/Driver_Motor/: motor_config.h motor_top.cpp motor_top.h motor_control.cpp motor_control.h
  group Package/Driver_Servo
    ../../../2_Package/Driver_Servo/: servo_config.h pan_tilt_head_ax.cpp pan_tilt_head_ax.h servo_digital.cpp servo_digital.h
  group Package/LIB_Robot_Wheel
    ../../../2_Package/LIB_Robot_Wheel/: robot_wheel_config.h robot_wheel_top.cpp robot_wheel_top.h tf_2wd.cpp tf_2wd.h tf_3wd.cpp tf_3wd.h tf_4wd.cpp tf_4wd.h
  group Package/LIB_HF_Link
    ../../../2_Package/LIB_HF_Link/: hf_link.cpp hf_link.h hf_link_port.cpp hf_link_port.h
  group Package/LIB_Sbus_Ppm
    ../../../2_Package/LIB_SBUS_PPM/: sbus_ppm_config.h sbus_ppm.cpp sbus_ppm.h
