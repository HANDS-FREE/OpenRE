# Keil uVision project Template_UCOSII.uvprojx, settings and files
target Template_UCOSII (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  c flags: Optim=1
  c include: .\;..\..\..\1_Processor\STM32F4\Start_Code;..\..\..\1_Processor\STM32F4\Start_Code\CMSIS;..\..\..\1_Processor\STM32F4\Start_Code\FWlib\inc;..\..\..\1_Processor\STM32F4\;..\..\..\1_Processor\BoardAbstract;..\..\..\3_OS\STM32F4\RTOS\uCOS-II\CONFIG;..\..\..\3_OS\STM32F4\RTOS\uCOS-II\CORE;..\..\..\3_OS\STM32F4\RTOS\uCOS-II\PORT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.cpp main_includes.h main_config.h stm32f4xx_it.cpp
  group Processor/BoardAbstract
    ../../../1_Processor/BoardAbstract/: board.h control_unit_v1.cpp control_unit_v2.cpp
  group Processor/Start_Code
    ../../../1_Processor/STM32F4/Start_Code/: stm32f4xx_conf.h
    ../../../1_Processor/STM32F4/Start_Code/CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
    ../../../1_Processor/STM32F4/Start_Code/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Processor/BSPLIB
    ../../../1_Processor/STM32F4/: bsplib.h
    ../../../1_Processor/STM32F4/BSPLIB/: adc_dac.c adc_dac.h can.c can.h delay.c delay.h encoder.c encoder.h flash.c flash.h i2c.c i2c.h nvic.c nvic.h pwm_in.c pwm_in.h pwm_out.c pwm_out.h rtc.c rtc.h spi.c spi.h timer.c timer.h usart.c usart.h wdg_wkup.c wdg_wkup.h
  group OS/RTOS/uCOSII-CORE
    ../../../3_OS/STM32F4/RTOS/uCOS-II/CORE/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group OS/RTOS/uCOSII-PORT
    ../../../3_OS/STM32F4/RTOS/uCOS-II/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group OS/RTOS/uCOSII-CONFIG
    ../../../3_OS/STM32F4/RTOS/uCOS-II/CONFIG/: includes.h os_cfg.h
